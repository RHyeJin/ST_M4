<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\uart1Test_PA9_PA10_strtok.ewp</path>
    </project>
    <batchBuild />
</workspace>
